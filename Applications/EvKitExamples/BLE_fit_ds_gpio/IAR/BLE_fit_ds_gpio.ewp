# IAR project BLE_fit_ds_gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: WSF_MS_PER_TICK=1; LL_DBG_PIN_ENABLED=TRUE; MXC_ASSERT_ENABLE=TRUE; WSF_ASSERT_ENABLED=TRUE; INIT_BROADCASTER; INIT_PERIPHERAL; INIT_ENCRYPTED; INIT_PHY; LHCI_ENABLE_VS=TRUE; BB_CLK_RATE_HZ=1600000; LCTR_CONN_NO_TIFS_REASSEMBLY=1; BB_ENABLE_INLINE_ENC_TX=1; BB_ENABLE_INLINE_DEC_RX=1; FORCE_PMU_WAKEUP=1; BACKUP_MODE=0; LL_ENABLE_TESTER=1; FORCE_SOFT_AES=1; TARGET=32665; TARGET_REV=0x4132; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BLE_fit_ds_gpio.srec
  ILINK.IlinkOutputFile: BLE_fit.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$\.iar\config\linker\MAX32665_BLECO_ECC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32665#0.5.5}$\.iar\config\linker\MAX32665_BLECO.icf
  group (top)
    ../: fit_main.c main.c stack_fit.c wakeup.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: rtc.c
  group CMSIS-Pack/Maxim Maxim BTLE _Bluetooth.Bluetooth LE - Exc Files.DTM Helper files.Lib files Included (default)_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/platform/max32665/: chci_drv.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/platform/max32665/: hci_tr.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.EvKit V1_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/Source/: led.c mx25.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: gpio.c
  group CMSIS-Pack/Maxim Maxim API _Device.Low Power_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/CMSIS/Device/Maxim/MAX32665/Source/IAR/: backup_max32665.s
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: lp.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: cipher.c flc.c mem_utils.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c sema.c
    RTE/Device/MAX32665_Cortex-M4/: cmain.s low_level_init.c max32665.h startup_max32665.s system_max32665.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: wdt.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: wut.c
  group CMSIS-Pack/Maxim Maxim API _Device.XiP Flash_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: spixf.c spixfc.c
  group CMSIS-Pack/Maxim Maxim BTLE _Bluetooth.Bluetooth LE_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/anpc/: anpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/apps/app/common/: app_db.c app_hw.c app_ui.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/apps/app/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/att/: att_main.c att_uuid.c attc_disc.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/bas/: bas_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/bb/: bb_ble_adv_master.c bb_ble_adv_master_ae.c bb_ble_adv_slave.c bb_ble_adv_slave_ae.c bb_ble_conn.c bb_ble_conn_master.c bb_ble_conn_slave.c bb_ble_main.c bb_ble_test.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/platform/common/sources/bb/ble/: bb_ble_pdufilt.c bb_ble_periodiclist.c bb_ble_reslist.c bb_ble_whitelist.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/common/bb/: bb_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/blpc/: blpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/blps/: blps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/cfg/: cfg_stack.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/platform/common/sources/chci/: chci_tr.c chci_tr_serial.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/cpp/: cpps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/cscp/: cscps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/dis/: dis_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/gap/: gap_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/glpc/: glpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/glps/: glps_db.c glps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/sensor/: gyro_main.c temp_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/hci/dual_chip/: hci_cmd.c hci_cmd_ae.c hci_cmd_cte.c hci_cmd_past.c hci_cmd_phy.c hci_core_ps.c hci_evt.c hci_vs_ae.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/hci/common/: hci_core.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/platform/max32665/: hci_drv.c hci_vs.c pal_nvm.c pal_rtc.c pal_stubs.c pal_sys.c wsf_cs.c wsf_os.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/hci/: hci_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/hid/: hid_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/apps/hidapp/: hidapp_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/hrps/: hrps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/htpc/: htpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/htps/: htps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: icc.c simo.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/init/: init.c init_ctr.c init_ctr_ext.c init_ext.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/lctr/: lctr_act_adv_master.c lctr_act_adv_master_ae.c lctr_act_adv_slave.c lctr_act_adv_slave_ae.c lctr_act_conn.c lctr_act_conn_master.c lctr_act_conn_master_ae.c lctr_act_enc.c lctr_act_enc_master.c lctr_act_init_master.c lctr_act_init_master_ae.c lctr_act_phy.c lctr_isr_adv_master.c lctr_isr_adv_master_ae.c lctr_isr_adv_slave.c lctr_isr_adv_slave_ae.c lctr_isr_conn.c lctr_isr_conn_master.c lctr_isr_conn_slave.c lctr_isr_init_master.c lctr_isr_init_master_ae.c lctr_main.c lctr_main_adv_master.c lctr_main_adv_master_ae.c lctr_main_adv_slave.c lctr_main_adv_slave_ae.c lctr_main_conn.c lctr_main_conn_cs2.c lctr_main_conn_data.c lctr_main_conn_master.c lctr_main_conn_slave.c lctr_main_enc_master.c lctr_main_enc_slave.c lctr_main_init_master.c lctr_main_init_master_ae.c lctr_main_master_phy.c lctr_main_priv.c lctr_main_sc.c lctr_main_slave_phy.c lctr_main_tester.c lctr_pdu_adv_master_ae.c lctr_pdu_adv_slave.c lctr_pdu_adv_slave_ae.c lctr_pdu_conn.c lctr_pdu_enc.c lctr_sm_adv_master.c lctr_sm_adv_master_ae.c lctr_sm_adv_slave.c lctr_sm_adv_slave_ae.c lctr_sm_conn_master.c lctr_sm_conn_slave.c lctr_sm_init_master.c lctr_sm_init_master_ae.c lctr_sm_llcp_conn.c lctr_sm_llcp_conn_master.c lctr_sm_llcp_conn_slave.c lctr_sm_llcp_enc_master.c lctr_sm_llcp_enc_slave.c lctr_sm_llcp_master_phy.c lctr_sm_llcp_slave_phy.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/lhci/: lhci_cmd.c lhci_cmd_adv_master.c lhci_cmd_adv_master_ae.c lhci_cmd_adv_priv.c lhci_cmd_adv_slave.c lhci_cmd_adv_slave_ae.c lhci_cmd_conn.c lhci_cmd_conn_master.c lhci_cmd_conn_master_ae.c lhci_cmd_conn_priv.c lhci_cmd_enc_master.c lhci_cmd_enc_slave.c lhci_cmd_phy.c lhci_cmd_sc.c lhci_evt.c lhci_evt_adv_master.c lhci_evt_adv_master_ae.c lhci_evt_adv_slave.c lhci_evt_adv_slave_ae.c lhci_evt_conn.c lhci_evt_conn_cs2.c lhci_evt_conn_master.c lhci_evt_conn_priv.c lhci_evt_enc_master.c lhci_evt_enc_slave.c lhci_evt_phy.c lhci_evt_sc.c lhci_evt_vs.c lhci_init.c lhci_init_adv_master.c lhci_init_adv_master_ae.c lhci_init_adv_priv.c lhci_init_adv_slave.c lhci_init_adv_slave_ae.c lhci_init_conn.c lhci_init_conn_cs2.c lhci_init_conn_master.c lhci_init_conn_master_ae.c lhci_init_conn_priv.c lhci_init_enc_master.c lhci_init_enc_slave.c lhci_init_phy.c lhci_init_sc.c lhci_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/platform/common/sources/ll/: lhci_cmd_vs_ext.c ll_math_ecc.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/platform/max32665/: lhci_vs.c ll_math_aes.c ll_tester.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/lib/IAR/: libphy_iar.a
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/ll/: ll_init.c ll_init_adv_master.c ll_init_adv_master_ae.c ll_init_adv_slave.c ll_init_adv_slave_ae.c ll_init_conn_cs2.c ll_init_conn_master.c ll_init_conn_slave.c ll_init_enc_master.c ll_init_enc_slave.c ll_init_init_master.c ll_init_init_master_ae.c ll_init_master_phy.c ll_init_priv.c ll_init_sc.c ll_init_slave_phy.c ll_main.c ll_main_adv_master.c ll_main_adv_master_ae.c ll_main_adv_slave.c ll_main_adv_slave_ae.c ll_main_conn.c ll_main_conn_master.c ll_main_conn_master_ae.c ll_main_conn_slave.c ll_main_diag.c ll_main_dtm.c ll_main_enc_master.c ll_main_enc_slave.c ll_main_phy.c ll_main_priv.c ll_main_sc.c ll_math.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/lmgr/: lmgr_events.c lmgr_main.c lmgr_main_adv_master_ae.c lmgr_main_adv_slave_ae.c lmgr_main_conn.c lmgr_main_master.c lmgr_main_priv.c lmgr_main_sc.c lmgr_main_slave.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/paspc/: paspc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/plxpc/: plxpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/plxps/: plxps_db.c plxps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/rscp/: rscps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/ble/sch/: sch_ble.c sch_rm.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/controller/sources/common/sch/: sch_list.c sch_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/scpps/: scpps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/sec/common/: sec_aes.c sec_cmac_hci.c sec_ecc_hci.c sec_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/sec/pal/: sec_ccm.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/tipc/: tipc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/udsc/: udsc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/link_layer/thirdparty/uecc/: uECC_ll.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/uribeacon/: uricfg_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/wdxc/: wdxc_ft.c wdxc_main.c wdxc_stream.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/wdxs/: wdxs_au.c wdxs_dc.c wdxs_ft.c wdxs_main.c wdxs_phy.c wdxs_stream.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/wpc/: wpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/wsf/sources/port/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_detoken.c wsf_efs.c wsf_heap.c wsf_msg.c wsf_nvm.c wsf_queue.c wsf_timer.c wsf_trace.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/BTLE/stack/ble-profiles/sources/profiles/wspc/: wspc_main.c
