# Keil uVision project BTLE_hci_uart.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.6.6
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: BLE_hci_uart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: WSF_MS_PER_TICK=1 MXC_ASSERT_ENABLE=TRUE WSF_ASSERT_ENABLED=TRUE INIT_BROADCASTER INIT_OBSERVER INIT_CENTRAL INIT_PERIPHERAL INIT_ENCRYPTED INIT_PHY LHCI_ENABLE_VS=TRUE BB_CLK_RATE_HZ=1600000 LCTR_CONN_NO_TIFS_REASSEMBLY=1 BB_ENABLE_INLINE_ENC_TX=1 BB_ENABLE_INLINE_DEC_RX=1 FORCE_PMU_WAKEUP=1 BTLE_APP_USE_LEGACY_API=TRUE BTLE_APP_USE_ACTIVE_SCANNING=TRUE LL_ENABLE_TESTER=1 HCI_UART=1 HCI_UART_MAP=MAP_A ENABLE_SDMA_UNIFIED_CONFIG=1 ENABLE_SOFT_AES=1 WDX_FTD_ATT_DEFAULT_PAYLOAD_LEN=256 CONSOLE_UART=0 TARGET=32665 TARGET_REV=0x4132
  c include: ..\..\BLE_hci_uart
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\ble_sdma.sct
  group Source
    ../: main.c hci_tr.c chci_drv.c stack_setup.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 0.6.6, Device:GPIO 0.6.6, Device:Startup 0.6.6, Device:Timers 0.6.6, Device:UART 0.6.6, Device:WUT 0.6.6, Device:XiP Flash 0.6.6, Bluetooth:Bluetooth LE - Exc Files:DTM Helper files 0.6.6, Bluetooth:Bluetooth LE 0.6.6
