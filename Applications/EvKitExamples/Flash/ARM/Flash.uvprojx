# Keil uVision project Flash.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.6.6
  cpu: IRAM(0x20005000,0x0007A000) IROM(0x20000000,0x00005000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Flash
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32665 TARGET_REV=0x4132
  c include: ...\..\Flash
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  memory RVCT9: RAM 0x20005000 size 0x7a000
  scatter file: .\Flash_RunFromRAM.sct
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 0.6.6, Device:FLC 0.6.6, Device:GPIO 0.6.6, Device:ICC 0.6.6, Device:Startup 0.6.6, Device:UART 0.6.6, Device:WUT 0.6.6, Device:XiP Flash 0.6.6
