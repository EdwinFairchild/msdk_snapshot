# Keil uVision project LCD.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.6.6
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: DMA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32665 TARGET_REV=0x4132
  c include: ..\lvgl;..\lvgl\lv_core;..\lvgl\lv_draw;..\lvgl\lv_fonts;..\lvgl\lv_hal;..\lvgl\lv_misc;..\lvgl\lv_objx;..\lvgl\lv_themes
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source
    ../: main.c
    ./: Abstract.txt
  group lv_core
    ../lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group lv_draw
    ../lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group lv_fonts
    ../lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group lv_hal
    ../lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group lv_objx
    ../lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group lv_themes
    ../lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 0.6.6, Device:DMA 0.6.6, Device:GPIO 0.6.6, Device:SPI 0.6.6, Device:Startup 0.6.6, Device:Timers 0.6.6, Device:UART 0.6.6, Device:WUT 0.6.6, Device:XiP Flash 0.6.6
