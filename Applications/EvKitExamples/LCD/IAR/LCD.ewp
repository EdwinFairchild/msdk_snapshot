# IAR project LCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32665; TARGET_REV=0x4132; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE; ..\lvgl\; ..\lvgl\lv_hal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ILINK.IlinkOutputFile: LCD.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$\.iar\config\linker\MAX32665.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ../: lv_conf.h main.c
  group lvgl
    ../lvgl/: lv_conf_templ.h lvgl.h
  group lvgl/docs
    ../lvgl/docs/: astyle_c astyle_h CODE_OF_CONDUCT.md CONTRIBUTING.md
  group lvgl/lv_core
    ../lvgl/lv_core/: lv_group.c lv_group.h lv_indev.c lv_indev.h lv_obj.c lv_obj.h lv_refr.c lv_refr.h lv_style.c lv_style.h lv_vdb.c lv_vdb.h
  group lvgl/lv_draw
    ../lvgl/lv_draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_rbasic.c lv_draw_rbasic.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_vbasic.c lv_draw_vbasic.h
  group lvgl/lv_fonts
    ../lvgl/lv_fonts/: lv_font_builtin.c lv_font_builtin.h lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c lv_fonts.mk
  group lvgl/lv_hal
    ../lvgl/lv_hal/: lv_hal.h lv_hal.mk lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lv_misc
    ../lvgl/lv_misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_circ.c lv_circ.h lv_color.c lv_color.h lv_font.c lv_font.h lv_fs.c lv_fs.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_misc.mk lv_symbol_def.h lv_task.c lv_task.h lv_templ.c lv_templ.h lv_txt.c lv_txt.h lv_ufs.c lv_ufs.h
  group lvgl/lv_objx
    ../lvgl/lv_objx/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnm.c lv_btnm.h lv_calendar.c lv_calendar.h lv_cb.c lv_cb.h lv_chart.c lv_chart.h lv_cont.c lv_cont.h lv_ddlist.c lv_ddlist.h lv_gauge.c lv_gauge.h lv_img.c lv_img.h lv_imgbtn.c lv_imgbtn.h lv_kb.c lv_kb.h lv_label.c lv_label.h lv_led.c lv_led.h lv_line.c lv_line.h lv_list.c lv_list.h lv_lmeter.c lv_lmeter.h lv_mbox.c lv_mbox.h lv_objx.mk lv_objx_templ.c lv_objx_templ.h lv_page.c lv_page.h lv_preload.c lv_preload.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_sw.c lv_sw.h lv_ta.c lv_ta.h lv_tabview.c lv_tabview.h lv_win.c lv_win.h
  group lvgl/lv_themes
    ../lvgl/lv_themes/: lv_theme.c lv_theme.h lv_theme_alien.c lv_theme_alien.h lv_theme_default.c lv_theme_default.h lv_theme_material.c lv_theme_material.h lv_theme_mono.c lv_theme_mono.h lv_theme_nemo.c lv_theme_nemo.h lv_theme_night.c lv_theme_night.h lv_theme_templ.c lv_theme_templ.h lv_theme_zen.c lv_theme_zen.h lv_themes.mk
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: spi.c spi17y.c
  group CMSIS-Pack/Maxim Maxim API _Device.XiP Flash_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: spixf.c spixfc.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: cipher.c flc.c mem_utils.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c sema.c
    ../RTE/Device/MAX32665_Cortex-M4/: cmain.s low_level_init.c max32665.h startup_max32665.s system_max32665.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: gpio.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.EvKit V1_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/Source/: led.c mx25.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: wut.c
