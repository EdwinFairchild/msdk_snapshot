# Keil uVision project USB_MassStorage.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.6.6
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: USB_MassStorage
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32665 TARGET_REV=0x4132
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source
    ../: main.c mscmem.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, File System:FatFs - SDHC 0.6.6, BSP:EvKit V1 0.6.6, USB:Core 0.6.6, USB:Device Class 0.6.6, Device:GPIO 0.6.6, Device:SDHC 0.6.6, Device:Startup 0.6.6, Device:Timers 0.6.6, Device:UART 0.6.6, Device:WUT 0.6.6, Device:XiP Flash 0.6.6, Device:XiP RAM 0.6.6
