# IAR project USB_MassStorage_SDHC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32665; TARGET_REV=0x4132; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: USB_MassStorage_SDHC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c mscmem.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: wut.c
  group CMSIS-Pack/Maxim FatFs _File System.FatFs - SDHC_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/SDHC/ff13/Source/: diskio.c ff.c ffsystem.c ffunicode.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/SDHC/Source/: sdhc_lib.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.EvKit V1_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Boards/Maxim/MAX32665_EVKIT/Common/Source/: led.c mx25.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: gpio.c
  group CMSIS-Pack/Maxim Maxim API _Device.SDHC_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: sdhc.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: cipher.c flc.c mem_utils.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c sema.c
    ../RTE/Device/MAX32665_Cortex-M4/: cmain.s low_level_init.c max32665.h startup_max32665.s system_max32665.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Maxim Maxim API _Device.XiP Flash_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: spixf.c spixfc.c
  group CMSIS-Pack/Maxim Maxim API _Device.XiP RAM_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAX32665PeriphDriver/Source/: spixr.c srcc.c
  group CMSIS-Pack/Maxim MAXUSB _USB.Core_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAXUSB/src/enumerate/: enumerate.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAXUSB/src/core/musbhsfc/: usb.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAXUSB/src/core/: usb_event.c
  group CMSIS-Pack/Maxim MAXUSB _USB.Device Class_0.6.6
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAXUSB/src/devclass/: cdc_acm.c hid_kbd.c hid_raw.c msc.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.6.6}$/Libraries/MAXUSB/src/util/: fifo.c
