# Keil uVision project BTLE_fit_ds.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.5.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: BLE_fit_ds
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: WSF_MS_PER_TICK=1 LL_DBG_PIN_ENABLED=TRUE MXC_ASSERT_ENABLE INIT_BROADCASTER INIT_PERIPHERAL INIT_ENCRYPTED LHCI_ENABLE_VS=TRUE BB_CLK_RATE_HZ=1600000 LCTR_CONN_NO_TIFS_REASSEMBLY=1 BB_ENABLE_INLINE_ENC_TX=1 BB_ENABLE_INLINE_DEC_RX=1 FORCE_PMU_WAKEUP=1
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\ble_sdma.sct
  group Source
    ../: main.c fit_main.c stack_fit.c wakeup.c
    ./: Abstract.txt backup.S hardfault.S
software components: CMSIS:CORE 5.1.2, BSP:EvKit V1 0.5.1, Device:GPIO 0.5.1, Device:Startup 0.5.1, Device:Timers 0.5.1, Device:UART 0.5.1, Device:XiP Flash 0.5.1, Bluetooth:Bluetooth LE 0.5.1
