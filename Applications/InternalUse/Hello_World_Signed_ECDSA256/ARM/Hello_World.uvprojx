# Keil uVision project Hello_World.uvprojx, settings and files
target Flash Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MAX32650 Maxim
  pack: Maxim.MAX32650.1.0.0-a
  cpu: IRAM(0x20000000,0x00100000) IROM(0x10000000,0x00300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hello_World
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=MAX32650, TARGET_NUM=32650, MXC_ASSERT_ENABLE, TARGET_REV=0x4131, BOARD=EvKit_V1
  c misc: --diag_suppress=1295,1296
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x100000
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, BSP:Board Support 1.0.0-a, Device:Startup 1.0.0-a, HAL:EV_KitV1 1.0.0-a, Peripherals:I2C 1.0.0-a, Peripherals:SPI 1.0.0-a, Peripherals:Timers 1.0.0-a, Peripherals:UART 1.0.0-a, Peripherals:XiP Flash 1.0.0-a
