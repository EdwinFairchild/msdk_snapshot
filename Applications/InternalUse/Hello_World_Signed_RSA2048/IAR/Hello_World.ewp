# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe826
  ICCARM.CCIncludePath2: ..; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
    RTE/: RTE_Components.h
  group CMSIS-Pack/Peripherals UART
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/MAX32650PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Peripherals Timers
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/MAX32650PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Peripherals SPI
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/MAX32650PeriphDriver/Source/: spi.c spi17y.c spid.c
  group CMSIS-Pack/Peripherals I2C
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/MAX32650PeriphDriver/Source/: i2c.c
  group CMSIS-Pack/Device Startup
    RTE/MAX32650/Maxim/: cmain.s low_level_init.c max32650.h system_max32650.c
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/MAX32650PeriphDriver/Source/: gpio.c icc.c lp.c mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c sema.c
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Libraries/Device/Maxim/MAX32650/Source/IAR/: startup_max32650.s
  group CMSIS-Pack/CMSIS CORE
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.2.0}$/CMSIS/Documentation/Core/html/: index.html
  group CMSIS-Pack/BSP Board Support
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Boards/Maxim/MAX32650_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/Boards/Maxim/MAX32650_EVKIT/Common/Source/: led.c mx25.c pb.c stdio.c
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.0.0-a}$/https:/datasheets.maximintegrated.com/en/ds/: MAX32650EVKIT.pdf
