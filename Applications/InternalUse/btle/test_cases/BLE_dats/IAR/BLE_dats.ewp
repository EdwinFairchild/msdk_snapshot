# IAR project BLE_dats.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: BLE_dats.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$\.iar\config\linker\MAX32665_BLECO.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c stack_dats.c dats_main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.EvKit V1_0.2.8-b
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Boards/Maxim/MAX32665_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Boards/Maxim/MAX32665_EVKIT/Common/Source/: led.c mx25.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_0.2.8-b
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Libraries/MAX32665PeriphDriver/Source/: gpio.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_0.2.8-b
    RTE/Device/MAX32665_Cortex-M4/: cmain.s low_level_init.c max32665.h startup_max32665.s system_max32665.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Libraries/MAX32665PeriphDriver/Source/: mxc_assert.c mxc_delay.c mxc_lock.c mxc_pins.c mxc_sys.c nvic_table.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_0.2.8-b
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Libraries/MAX32665PeriphDriver/Source/: tmr.c tmr_utils.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_0.2.8-b
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Libraries/MAX32665PeriphDriver/Source/: uart.c
  group CMSIS-Pack/Maxim Maxim API _Device.XiP Flash_0.2.8-b
    ${CMSIS_PACK_PATH_Maxim#MAX32665#0.2.9-c}$/Libraries/MAX32665PeriphDriver/Source/: spixf.c spixfc.c
