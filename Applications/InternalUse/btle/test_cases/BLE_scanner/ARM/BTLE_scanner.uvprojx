# Keil uVision project BTLE_scanner.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.2.9-c
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: BLE_scanner
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source
    ../: main.c scanner_main.c stack_scanner.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.2, BSP:EvKit V1 0.2.9-c, Device:GPIO 0.2.9-c, Device:Startup 0.2.9-c, Device:Timers 0.2.9-c, Device:UART 0.2.9-c, Device:XiP Flash 0.2.9-c, Bluetooth:Bluetooth LE 0.2.9-c
